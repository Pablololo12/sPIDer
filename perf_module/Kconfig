## perf_module/Kconfig
```kconfig
config HWCOUNTER
tristate "Driver for hardware counters"
help
  A driver that reads and expose hardware counters
```
